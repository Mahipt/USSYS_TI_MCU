# Keil uVision project USSYS_TI_MCU.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: MSPM0L2228 Texas Instruments
  pack: TexasInstruments.MSPM0L122X_L222X_DFP.1.1.1
  cpu: IRAM(0x20200000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USSYS_TI_MCU
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20200000 size 0x8000
software components: CMSIS:CORE 6.1.1
